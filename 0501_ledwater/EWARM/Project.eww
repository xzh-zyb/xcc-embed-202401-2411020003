<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\0501_ledwater.ewp</path>
  </project>
  <batchBuild />
</workspace>
